Commit message: Fixed twitching kinect

File: kinova_moveit/kinova_arm_moveit_demo/urdf/fakeBot.urdf (robot description, URDF)
Before this commit: robot fakeBot, 1 links, 0 joints
Links:
- added link base_link
Joints:
- added joint movement: type floating, parent world, child base_link
